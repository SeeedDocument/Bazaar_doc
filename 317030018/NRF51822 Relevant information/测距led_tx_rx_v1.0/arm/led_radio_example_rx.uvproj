# Keil uVision project led_radio_example_rx.uvproj, settings and files
target nRF51822 (ARM-ADS)
  device: nRF51 Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: led_radio_example_rx +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10001 DO_NOT_USE_DEPRECATED
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../../../../Source/: keil_arm_uv4.lnt
    ../: main_rx.c radio_config.c
  group core
    ../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../Source/templates/: system_nrf51.c
  group lib
    ../../../../Source/simple_uart/: simple_uart.c
    ../../../../Source/nrf_delay/: nrf_delay.c
target nRF51822_S110 (ARM-ADS)
  device: nRF51 Nordic
  cpu: as above
  output: led_radio_example_rx_s110 +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10001 DO_NOT_USE_DEPRECATED
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x20000
  memory RVCT9: RAM 0x20002000 size 0x2000
